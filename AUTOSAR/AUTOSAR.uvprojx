# Keil uVision project AUTOSAR.uvprojx, settings and files
target AUTOSAR (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AUTOSAR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Project
    ./: Port.h Port.c user_Macros_Types.h Port_Cfg.h Std_Types.h Det.h Port_Lcfg.c app.c Det.c Det_cfg.c Det_cfg.h Platform_types.h Dio.h Dio_Cfg.h Dio_MemMap.h Compiler.h Dio_Lcfg.c SchM_Dio.h Dio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
